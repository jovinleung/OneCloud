## OneCloud-ImmortalWrt/target/linux/amlogic/image/Config.in
```kconfig
config TARGET_KERNEL_PARTSIZE
	int
	default 64

config TARGET_ROOTFS_PARTSIZE
	int
	default 512
```
